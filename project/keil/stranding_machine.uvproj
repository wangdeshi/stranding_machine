# Keil uVision project stranding_machine.uvproj, settings and files
target stranding_machine (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: stranding_machine +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\common;..\..\drivers;..\..\hal;..\..\init;..\..\modules
  group boot
    ./: STARTUP.A51
  group common
    ../../common/: type.h util.c util.h
  group drivers
    ../../drivers/: eeprom_24c02.c eeprom_24c02.h lcd_12864.c lcd_12864.h
  group hal
    ../../hal/: eeprom.c eeprom.h input.c input.h key.c key.h lcd.c lcd.h output.c output.h
  group modules
    ../../modules/: beer.c beer.h display.c display.h font.h strand.c strand.h
  group init
    ../../init/: global.h main.c
